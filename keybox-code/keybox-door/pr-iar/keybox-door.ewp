# IAR project keybox-door.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\device\include; ..\frame\include; ..\user\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: keybox-door.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ./: main.c
    ../user/: register_device.c
  group device
    ../device/: electromagnet.c iwdg.c led.c light.c setp_moto.c uart.c
  group fsm
    ../frame/: event.c stime.c
