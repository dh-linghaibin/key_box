# IAR project keybox-master.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207M8 STM8S207M8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\device\include; ..\frame\include; ..\os\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: keybox-master.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../user/: main.c
  group device
    ../device/: button.c lcd.c led.c receipt.c setp_moto.c uart.c voice.c
  group fsm
    ../frame/: event.c stime.c
  group os
    ../os/: l_os.c
